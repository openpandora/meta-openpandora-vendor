require task-sdk-host.bb

DESCRIPTION = "Host packages for OpenPandora SDK"
LICENSE = "MIT"
ALLOW_EMPTY = "1"
