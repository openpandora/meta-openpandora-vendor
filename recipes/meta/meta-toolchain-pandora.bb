# OpenPandora Sample toolchain/SDK scripts.

PR = "r1"
TOOLCHAIN_HOST_TASK = "task-pandora-toolchain-host"
TOOLCHAIN_TARGET_TASK = "task-pandora-toolchain-target"

require meta-toolchain.bb

SDK_SUFFIX = "toolchain-openpandora"
