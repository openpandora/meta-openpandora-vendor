DESCRIPTION = "Target packages for OpenPandora SDK"

PR = "r5"
ALLOW_EMPTY = "1"

RDEPENDS_${PN} += " \
  task-pandora-sdk-full \
"
